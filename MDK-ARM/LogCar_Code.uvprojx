# Keil uVision project LogCar_Code.uvprojx, settings and files
target LogCar_Code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LogCar_Code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_THREAD_SAFE_STRATEGY=4,USE_WG=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Applications/kinematics;../Applications/letter_shell;../Applications/letter_shell/src;../Applications/letter_shell/log;../Applications/letter_shell/shell_enhance;../Applications/nav;../Applications/nav/localization;../Applications/nav/trajectory_tracking;../Applications/nav/utils;../Drivers/User/ADC;../Drivers/User/MISC;../Drivers/User/OPS;../Drivers/User/RTOS;../Drivers/User/SERVO;../Drivers/User/STEP;../Drivers/User/STEP/driver;../Drivers/User/TRACK
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  link misc: --keep shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Kinetics
    ../Applications/kinematics/: mecanum_kinematics.c
  group lettershell
    ../Applications/letter_shell/: shell_port.c
    ../Applications/letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Applications/letter_shell/log/: log.c
    ../Applications/letter_shell/shell_enhance/: shell_cmd_group.c
    ../Applications/letter_shell/game/: game.c 2048.c
  group nav
    ../Applications/nav/localization/: nav_local.c
    ../Applications/nav/trajectory_tracking/: nav_tracker.c
    ../Applications/nav/utils/: nav_math.c
  group battery
    ../Drivers/User/ADC/: battery.c
  group misc
    ../Drivers/User/MISC/: message.c
  group ops
    ../Drivers/User/OPS/: ops.c
  group rtos
    ../Drivers/User/RTOS/: rtos_utils.c
  group servo
    ../Drivers/User/SERVO/: servo_driver.c servo_port.c
  group step
    ../Drivers/User/STEP/driver/: step_ttl.c ZDT_V5_Driver.c
    ../Drivers/User/STEP/: step_port.c
  group track
    ../Drivers/User/TRACK/: track.c
software components: CMSIS:CORE 6.2.0
